# IAR project SampleApp.ewp, settings and files
configuration CoordinatorEB (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\derivatives\Chipcon\CC2430.i51
  ICC8051.CCIncludePaths: $TOOLKIT_DIR$\inc\; $TOOLKIT_DIR$\inc\clib; $PROJ_DIR$; ..\Source; ..\..\..\ZMain\TI2430DB; ..\..\..\..\..\Components\mt; ..\..\..\..\..\Components\hal\include; ..\..\..\..\..\Components\hal\target\CC2430EB; ..\..\..\..\..\Components\osal\mcu\ccsoc; ..\..\..\..\..\Components\osal\include; ..\..\..\..\..\Components\stack\af; ..\..\..\..\..\Components\stack\nwk; ..\..\..\..\..\Components\stack\sec; ..\..\..\..\..\Components\stack\sys; ..\..\..\..\..\Components\stack\zdo; ..\..\..\..\..\Components\zmac\f8w; ..\..\..\..\..\Components\zmac; ..\..\..\..\..\Components\services\saddr; ..\..\..\..\..\Components\services\sdata; ..\..\..\..\..\Components\mac\include; ..\..\..\..\..\Components\mac\high_level; ..\..\..\..\..\Components\mac\low_level\srf03; ..\..\..\..\..\Components\mac\low_level\srf03\single_chip
  ICC8051.CCDefines: CC2430EB; ZTOOL_P1; MT_TASK; MT_ZDO_FUNC
  ICC8051.CCDiagSuppress: Pe001,Pa010
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  XLINK.XclFile: ..\..\..\Tools\CC2430DB\f8w2430.xcl
configuration RouterEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2430EB; ZTOOL_P1; MT_TASK
configuration EndDeviceEB (8051, debug)
  as the first configuration, except:
  ICC8051.CCDefines: CC2430EB; NWK_AUTO_POLL; ZTOOL_P1; MT_TASK
  group App
    ../../../../../Components/wxl/source/: Font.c menu_lcd.c
    ../Source/: OSAL_SampleApp.c SampleApp.c SampleApp.h SampleAppHw.h
    Source/: SampleAppHw.c
  group HAL/Common
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/hal/common/: hal_assert.c hal_drivers.c
  group HAL/Include
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/hal/include/: hal_adc.h hal_assert.h hal_board.h hal_ccm.h hal_defs.h hal_drivers.h hal_key.h hal_lcd.h hal_led.h hal_sleep.h hal_timer.h hal_uart.h
  group HAL/Target/CC2430DB/Config
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/hal/target/CC2430DB/: hal_board_cfg.h hal_target.c hal_target.h
  group HAL/Target/CC2430DB/Drivers
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/hal/target/CC2430DB/: hal_adc.c hal_dma.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_timer.c hal_uart.c
  group HAL/Target/CC2430DB/Includes
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/hal/target/CC2430DB/: hal_aes.h hal_mailbox.h hal_mcu.h hal_types.h
  group HAL/Target/CC2430EB/Config
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/hal/target/CC2430EB/: hal_board_cfg.h hal_target.c hal_target.h
  group HAL/Target/CC2430EB/Drivers
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/hal/target/CC2430EB/: hal_adc.c hal_dma.c hal_key.c hal_lcd.c hal_led.c hal_sleep.c hal_timer.c hal_uart.c
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/wxl/source/: wait.c wxl_uart.c
  group HAL/Target/CC2430EB/Includes
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/hal/target/CC2430EB/: hal_aes.h hal_mailbox.h hal_mcu.h hal_types.h
  group MAC/High Level
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/mac/high_level/: mac_cfg.c mac_high_level.h mac_pib.h mac_spec.h
  group MAC/Include
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/mac/include/: mac_api.h
  group MAC/Low Level/Common
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/mac/low_level/srf03/: mac_assert.h mac_backoff_timer.c mac_backoff_timer.h mac_low_level.c mac_low_level.h mac_radio.c mac_radio.h mac_random.c mac_random.h mac_rx.c mac_rx.h mac_rx_onoff.c mac_rx_onoff.h mac_sleep.c mac_sleep.h mac_tx.c mac_tx.h
  group MAC/Low Level/System
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/mac/low_level/srf03/single_chip/: mac_csp_tx.c mac_csp_tx.h mac_mcu.c mac_mcu.h mac_mem.c mac_mem.h mac_radio_defs.c mac_radio_defs.h
  group MT
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/mt/: DebugTrace.c DebugTrace.h MT_AF.c MT_AF.h MT_NWK.c MT_NWK.h MT_ZDO.c MT_ZDO.h MTEL.c MTEL.h SPIMgr.c SPIMgr.h
  group NWK
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/stack/nwk/: AddrMgr.h APS.h aps_groups.h aps_util.h APSMEDE.h AssocList.h BindingTable.h NLMEDE.h nwk.h nwk_bufs.h nwk_globals.c nwk_globals.h nwk_util.h reflecttrack.h rtg.h
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/stack/sys/: ZGlobals.c ZGlobals.h
  group OSAL
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/osal/mcu/ccsoc/: AccessCodeSpace.s51 flashDmaTrigger.s51 FlashErasePage.s51 OSAL_Nv.c OSAL_Nv.h
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/osal/common/: OSAL.c OSAL_Memory.c OSAL_PwrMgr.c OSAL_Tasks.c OSAL_Timers.c
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/osal/include/: OSAL.h OSAL_Custom.h OSAL_Memory.h OSAL_PwrMgr.h OSAL_Tasks.h OSAL_Timers.h ZComDef.h
  group Profile
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/stack/af/: AF.c AF.h
  group Security
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/stack/sec/: ssp.h ssp_hash.h
  group Services
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/services/saddr/: saddr.c saddr.h
  group Tools
    ../../../Tools/CC2430DB/: f8w2430.xcl f8wConfig.cfg f8wCoord.cfg f8wEndev.cfg f8wRouter.cfg
  group ZDO
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/stack/zdo/: ZDApp.c ZDApp.h ZDCache.c ZDCache.h ZDConfig.c ZDConfig.h ZDObject.c ZDObject.h ZDProfile.c ZDProfile.h ZDSecMgr.c ZDSecMgr.h
  group ZMac
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/zmac/f8w/: zmac.c zmac_cb.c zmac_internal.h
    $EW_DIR$/../../../Texas Instruments/ZStack-1.4.2-1.1.0/Components/zmac/: ZMAC.h
  group ZMain
    ../../../ZMain/TI2430DB/: chipcon_banked_code_support.s51 chipcon_cexit.s51 chipcon_cstartup.s51 OnBoard.c OnBoard.h ZMain.c
