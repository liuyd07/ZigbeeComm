<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SampleApp.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>Build All</name>
      <member>
        <project>SampleApp</project>
        <configuration>CoordinatorDB</configuration>
      </member>
      <member>
        <project>SampleApp</project>
        <configuration>CoordinatorEB</configuration>
      </member>
      <member>
        <project>SampleApp</project>
        <configuration>RouterDB</configuration>
      </member>
      <member>
        <project>SampleApp</project>
        <configuration>RouterEB</configuration>
      </member>
      <member>
        <project>SampleApp</project>
        <configuration>EndDeviceDB</configuration>
      </member>
      <member>
        <project>SampleApp</project>
        <configuration>EndDeviceEB</configuration>
      </member>
      <member>
        <project>SampleApp</project>
        <configuration>DemoDB</configuration>
      </member>
      <member>
        <project>SampleApp</project>
        <configuration>DemoEB</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


